# Keil uVision project ASFS_app.uvprojx, settings and files
target SX1261MB1BAS (6220000::V6.22::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cad +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,USE_FULL_LL_DRIVER,SX1261MB1BAS
  c include: ..\..\..\..\common\inc;..\..\..\..\libs\smtc-hal-mcu\inc;..\..\..\..\libs\smtc-hal-mcu-stm32l4\inc;..\..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Drivers\CMSIS\Core\Include;..\..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Projects\STM32L476G-EVAL\Templates\Inc;..\..\..\..\libs\smtc-shields\common\inc;..\..\..\..\libs\smtc-shields\sx126x\inc;..\..\..\..\libs\smtc_dbpsk_driver\src;..\..\..\common;..\..\..\common\printers\;..\..\..\sx126x_driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ../../../libs/smtc-hal-mcu-stm32l4/third_party/STM32CubeL4/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l476xx.s
  group Application/User
    ../../common/: apps_common.c
    ../../../common/src/: smtc_hal_dbg_trace.c smtc_shield_pinout_mapping.c common_version.c uart_init.c
    ../: main_ASFS_App.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../libs/smtc-hal-mcu-stm32l4/third_party/STM32CubeL4/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_spi.c stm32l4xx_ll_tim.c stm32l4xx_ll_lptim.c stm32l4xx_ll_usart.c stm32l4xx_ll_rcc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_pwr.c stm32l4xx_ll_exti.c stm32l4xx_ll_utils.c
  group Drivers/CMSIS
    ../../../libs/smtc-hal-mcu-stm32l4/third_party/STM32CubeL4/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group radio_driver
    ../../sx126x_driver/src/: sx126x.c
  group smtc_hal
    ../../../libs/smtc-hal-mcu-stm32l4/src/: smtc_hal_mcu_gpio_stm32l4.c smtc_hal_mcu_rng_stm32l4.c smtc_hal_mcu_uart_stm32l4.c smtc_hal_mcu_timer_stm32l4.c smtc_hal_mcu_stm32l4.c smtc_hal_mcu_spi_stm32l4.c
  group radio_hal
    ../../common/: sx126x_hal.c
  group shields
    ../../../libs/smtc-shields/sx126x/src/: smtc_shield_sx1261mb2bas.c
    ../../../libs/smtc_dbpsk_driver/src/: smtc_dbpsk.c
  group radio_driver_printers
    ../../common/printers/: sx126x_str.c
target SX1261MB1CAS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: as above
  output: cad +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,USE_FULL_LL_DRIVER,SX1261MB1CAS
  c include: ..\..\..\..\common\inc;..\..\..\..\libs\smtc-hal-mcu\inc;..\..\..\..\libs\smtc-hal-mcu-stm32l4\inc;..\..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Drivers\CMSIS\Core\Include;..\..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Projects\STM32L476G-EVAL\Templates\Inc;..\..\..\..\libs\smtc-shields\common\inc;..\..\..\..\libs\smtc-shields\sx126x\inc;..\..\..\..\libs\smtc_dbpsk_driver\src;..\..\..\common;..\..\..\common\printers\;..\..\..\sx126x_driver\src;
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target SX1261MB2BAS (6220000::V6.22::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: as above
  output: ASFS +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,USE_FULL_LL_DRIVER,SX1261MB2BAS
  c include: ..\..\..\common\inc;..\..\..\libs\smtc-hal-mcu\inc;..\..\..\libs\smtc-hal-mcu-stm32l4\inc;..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Drivers\CMSIS\Core\Include;..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\libs\smtc-hal-mcu-stm32l4\third_party\STM32CubeL4\Projects\STM32L476G-EVAL\Templates\Inc;..\..\..\libs\smtc-shields\common\inc;..\..\..\libs\smtc-shields\sx126x\inc;..\..\..\libs\smtc_dbpsk_driver\src;..\..\common;..\..\common\printers\;..\..\sx126x_driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target SX1268MB1GAS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: as above
  output: cad +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,USE_FULL_LL_DRIVER,SX1268MB1GAS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target SX1262MB1CAS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: as above
  output: cad +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,USE_FULL_LL_DRIVER,SX1262MB1CAS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target SX1262MB1CBS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: as above
  output: cad +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,USE_FULL_LL_DRIVER,SX1262MB1CBS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target SX1262MB1DAS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: as above
  output: cad +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,USE_FULL_LL_DRIVER,SX1262MB1DAS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target SX1262MB1PAS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: as above
  output: cad +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,USE_FULL_LL_DRIVER,SX1262MB1PAS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target SX1262MB2CAS (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: as above
  output: cad +hex
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L476xx,NUCLEO_L476RG,USE_FULL_LL_DRIVER,SX1262MB2CAS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
software components: CMSIS:CORE 6.1.0
